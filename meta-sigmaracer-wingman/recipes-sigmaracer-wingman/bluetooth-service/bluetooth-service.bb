SUMMARY = "Sigma Racer Wingman bluetooth daemon"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SIGMARACER_WINGMAN_SERVICE_NAME = "bluetooth"

inherit sigmaracer-wingman-stub-service
