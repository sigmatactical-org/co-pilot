# sigmaracer-wingman-qemu is qemux86-64 under a custom MACHINE name
COMPATIBLE_MACHINE:sigmaracer-wingman-qemu = "sigmaracer-wingman-qemu"
KMACHINE:sigmaracer-wingman-qemu ?= "qemux86-64"
