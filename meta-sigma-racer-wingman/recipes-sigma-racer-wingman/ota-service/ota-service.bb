SUMMARY = "Sigma Racer Wingman ota daemon"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SIGMA_RACER_WINGMAN_SERVICE_NAME = "ota"

inherit sigma-racer-wingman-stub-service
