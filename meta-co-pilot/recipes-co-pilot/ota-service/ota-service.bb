SUMMARY = "Co-Pilot ota daemon"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

CO_PILOT_SERVICE_NAME = "ota"

inherit co-pilot-stub-service
