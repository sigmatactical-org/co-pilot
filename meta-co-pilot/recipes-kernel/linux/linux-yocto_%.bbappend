# co-pilot-qemu is qemux86-64 under a custom MACHINE name
COMPATIBLE_MACHINE:co-pilot-qemu = "co-pilot-qemu"
KMACHINE:co-pilot-qemu ?= "qemux86-64"
