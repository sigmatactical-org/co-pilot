# Minimal Weston — compositor only; instrumentation is the sole UI client
PACKAGECONFIG:remove = "xwayland remoting pipewire fullscreen-shell kiosk-shell"
